# Keil uVision project LED_brightness.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_brightness
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source_files
    ./MCAL/TIMERS/: TIMERS_prog.c
    ./MCAL/NVIC/: NVIC_prog.c
    ./: main.c
    ./APP/: APP.c
    ./HAL/BUTTON/: Button.c
    ./HAL/LED/: LED.c
    ./MCAL/DIO/: DIO_prog.c
    ./SERVICE/DELAY/: DELAY.c
    ./MCAL/SYSTICK/: SYSTICK_prog.c
    ./HAL/SW_PWM/: SW_PWM.c
    ./MCAL/SYS_CONTROL/: SYS_CONTROL_prog.c
  group Header_files
    ./MCAL/TIMERS/: TIMERS_config.h TIMERS_interface.h TIMERS_private.h
    ./MCAL/NVIC/: NVIC_config.h NVIC_interface.h NVIC_private.h
    ./MCAL/DIO/: DIO_config.h DIO_interface.h DIO_private.h
    ./HAL/LED/: LED.h
    ./HAL/BUTTON/: Button.h
    ./APP/: APP.h
    ./SERVICE/DELAY/: DELAY.h
    ./MCAL/SYSTICK/: SYSTICK_config.h SYSTICK_interface.h SYSTICK_private.h
    ./HAL/SW_PWM/: SW_PWM.h
    ./MCAL/SYS_CONTROL/: SYS_CONTROL_private.h SYS_CONTROL_interface.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.1
